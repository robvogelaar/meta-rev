SUMMARY = "Packagegroup containing efl components"

LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = "\
    efl elementary\
"
